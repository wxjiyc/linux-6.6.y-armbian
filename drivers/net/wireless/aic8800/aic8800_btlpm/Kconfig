## drivers/net/wireless/aic8800/aic8800_btlpm/Kconfig
```kconfig
config AIC8800_BTLPM_SUPPORT
	tristate "AIC8800 bluetooth Support"
	default m
	help
	  This is support for aic bluetooh driver.
```
